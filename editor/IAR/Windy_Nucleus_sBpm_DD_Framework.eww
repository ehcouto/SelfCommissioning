<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Windy_Nucleus_sBpm_DD_Framework.ewp</path>
  </project>
  <batchBuild/>
</workspace>


